# Keil uVision project Platform.uvprojx, settings and files
target STM32F746G-Discovery (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: RAM 0x2004f800 size 0x800
  memory RVCT9: RAM 0x20010000 size 0x3f800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f746.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: arduino.c arduino.h retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/Inc/: stm32f7xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:LCD 1.1.1, Board Support:Drivers:SDRAM 1.1.1, CMSIS Driver:Ethernet MAC 1.9.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:MCI 1.11.0, CMSIS Driver:SPI 1.11.0, CMSIS Driver:USART 1.16.0, CMSIS Driver:VIO:Board 1.1.0, Device:STM32Cube HAL:Common 1.2.9, Device:STM32Cube HAL:Cortex 1.2.9, Device:STM32Cube HAL:DMA 1.2.9, Device:STM32Cube HAL:DMA2D 1.2.9, Device:STM32Cube HAL:ETH 1.2.9, Device:STM32Cube HAL:GPIO 1.2.9, Device:STM32Cube HAL:I2C 1.2.9, Device:STM32Cube HAL:LTDC 1.2.9, Device:STM32Cube HAL:MMC 1.2.9, Device:STM32Cube HAL:PWR 1.2.9, Device:STM32Cube HAL:RCC 1.2.9, Device:STM32Cube HAL:RNG 1.2.9, Device:STM32Cube HAL:SD 1.2.9, Device:STM32Cube HAL:SDRAM 1.2.9, Device:STM32Cube HAL:SPI 1.2.9, Device:STM32Cube HAL:UART 1.2.9, Device:STM32Cube LL:Common 1.2.9, Device:STM32Cube LL:PWR 1.2.9, Device:STM32Cube LL:RCC 1.2.9, Device:STM32Cube LL:UTILS 1.2.9, Device:Startup 1.2.5
