# Keil uVision project Platform.uvprojx, settings and files
target STM32H7B3I-DK (6160000::V6.16::ARMCLANG)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT8: RAM 0x2001e000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: .\stm32h7b3.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H7B3LIHxQ/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H7B3LIHxQ/STCubeGenerated/Inc/: stm32h7xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32H7B3LIHxQ/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Components:FT5336 2.0.1, Board Support:Components:IS42S16800J 1.0.0, Board Support:Components:MX25LM51245G 2.0.2, Board Support:Components:RK043FN48H 1.0.3, Board Support:Drivers:BUS 1.0.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:LCD 1.0.0, Board Support:Drivers:OSPI 1.0.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:Drivers:Touch Screen 1.0.0, CMSIS Driver:MCI 1.7.0, CMSIS Driver:SPI 1.2.0, CMSIS Driver:USART 1.3.0, CMSIS Driver:VIO:Board 1.0.0, CMSIS Driver:WiFi:ISM43362 1.9.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:DMA2D 1.9.0, Device:STM32Cube HAL:EXTI 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:I2S 1.9.0, Device:STM32Cube HAL:IRDA 1.9.0, Device:STM32Cube HAL:LTDC 1.9.0, Device:STM32Cube HAL:MDMA 1.9.0, Device:STM32Cube HAL:MMC 1.9.0, Device:STM32Cube HAL:OSPI 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:RTC 1.9.0, Device:STM32Cube HAL:SD 1.9.0, Device:STM32Cube HAL:SDRAM 1.9.0, Device:STM32Cube HAL:SPI 1.9.0, Device:STM32Cube HAL:Smartcard 1.9.0, Device:STM32Cube HAL:TIM 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:STM32Cube HAL:USART 1.9.0, Device:Startup 1.9.0
