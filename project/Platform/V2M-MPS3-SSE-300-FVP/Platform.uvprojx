# Keil uVision project Platform.uvprojx, settings and files
target V2M-MPS3-SSE-300-FVP (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_VSOCKET_BASE="0x4FEE0000UL"
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  group App
    ./: Platform.c
  group Board
    ./: main.c main.h fvp_config.txt
  group Board IO
    ./Board_IO/: retarget_stdio.c vio_V2M-MPS3-SSE-300.c
  group Board Driver
    ./Board_Driver/: ETH_LAN91C111.c ETH_LAN91C111.h
  group Documentation
    ./: README.md
software components: CMSIS Driver:Ethernet:Custom 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS Driver:VIO:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:IO 1.0.0, Native Driver:UART 1.0.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
