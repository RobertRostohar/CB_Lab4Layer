# Keil uVision project AWS_MQTT_MutualAuth.uvprojx, settings and files
target V2M-MPS3-SSE-300-FVP (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: ARM_VSOCKET_BASE="0x4FEE0000UL"
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: ./RTE/Device/SSE-300-MPS3/fvp_sse300_mps3_s.sct
  link misc: --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group App
    ./: app_main.c network_startup.c socket_startup.c
  group Documentation
    ./: README.md
  group demos_common_pkcs11_helpers
    ./amazon-freertos/demos/common/pkcs11_helpers/: pkcs11_helpers.c pkcs11_helpers.h
  group demos_coreMQTT
    ./amazon-freertos/demos/coreMQTT/: mqtt_demo_mutual_auth.c
  group demos_demo_runner
    ./amazon-freertos/demos/demo_runner/: aws_demo.c iot_demo_freertos.c iot_demo_runner.c
  group demos_include
    ./amazon-freertos/demos/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_metrics.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h
  group demos_network_manager
    ./amazon-freertos/demos/network_manager/: aws_iot_network_manager.c iot_network_manager_private.h
  group libraries_abstractions_platform_freertos
    ./amazon-freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c
    ./amazon-freertos/libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h
  group libraries_abstractions_platform_include
    ./amazon-freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h
    ./amazon-freertos/libraries/abstractions/platform/include/types/: iot_network_types.h iot_platform_types.h
  group libraries_abstractions_secure_sockets
    ./amazon-freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h
  group libraries_abstractions_transport_secure_sockets
    ./amazon-freertos/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c transport_secure_sockets.h
  group libraries_abstractions_wifi
    ./amazon-freertos/libraries/abstractions/wifi/include/: iot_wifi.h
  group libraries_c_sdk_standard_common
    ./amazon-freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group libraries_c_sdk_standard_common_include
    ./amazon-freertos/libraries/c_sdk/standard/common/include/: iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_taskpool.h
    ./amazon-freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
    ./amazon-freertos/libraries/c_sdk/standard/common/include/types/: iot_taskpool_types.h
  group libraries_c_sdk_standard_common_taskpool
    ./amazon-freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries_logging
    ./amazon-freertos/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
    ./amazon-freertos/libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group libraries_freertos_plus_standard_crypto
    ./amazon-freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
    ./amazon-freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries_freertos_plus_standard_tls
    ./amazon-freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
    ./amazon-freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group config_files
    ./config_files/: aws_demo_config.h aws_iot_network_config.h aws_mbedtls_config.h core_mqtt_config.h core_pkcs11_config.h iot_config.h iot_secure_sockets_config.h mqtt_demo_mutual_auth_config.h FreeRTOSIPConfig.h
  group interfaces
    ./Interfaces/: core_pkcs11_pal.c threading_alt.h iot_secure_sockets.c
  group Board
    ./: main.c main.h fvp_config.txt
  group Board IO
    ./Board_IO/: retarget_stdio.c vio_V2M-MPS3-SSE-300.c
  group Board Driver
    ./Board_Driver/: ETH_LAN91C111.c ETH_LAN91C111.h
  group VSocket
    ./vsocket/: iot_socket.c
software components: RTOS:Config 10.4.3, RTOS:Core 10.4.3, RTOS:Event Groups 10.4.3, RTOS:Heap 10.4.3, RTOS:Stream Buffer 10.4.3, RTOS:Timers 10.4.3, CMSIS Driver:Ethernet:Custom 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS Driver:VIO:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.4.3, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:IO 1.0.0, Native Driver:UART 1.0.0, Security:mbed TLS 2.24.0, FreeRTOS:backoffAlgorithm 1.0.0, FreeRTOS:coreMQTT Agent 1.0.1, FreeRTOS:coreMQTT 1.1.0, FreeRTOS:corePKCS11 3.0.0, Security:PKCS11 3.0.0, Compiler:Event Recorder 1.5.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, IoT Utility:Socket:Custom 1.0.0
